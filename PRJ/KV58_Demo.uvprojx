# Keil uVision project KV58_Demo.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKV58F1M0xxx24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x2F000000,0x00010000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: KV58_Demo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG,CPU_MKV58F1M0VLQ24, TWR_KV58F220M, TOWER,ARM_MATH_CM7,__FPU_PRESENT=1,__CC_ARM
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\SRC\STARTUP\CMSIS\Include;..\SRC\STARTUP\Device;..\SRC\FWLIB\include;..\SRC\HARDWARE\include;..\SRC\USER
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: ..\SRC\STARTUP\Device\MKV58F1M0xxx24_flash.scf
  link misc: --remove
  group Startup
    ../SRC/STARTUP/Device/: startup_MKV58F24.s system_MKV58F24.c
  group User
    ../SRC/USER/: include.h isr.c isr.h main.c
  group FWLIB
    ../SRC/FWLIB/source/: fsl_adc16.c fsl_aoi.c fsl_clock.c fsl_common.c fsl_cmp.c fsl_crc.c fsl_dac.c fsl_dmamux.c fsl_dspi.c fsl_dspi_edma.c fsl_edma.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flash.c fsl_flexbus.c fsl_flexcan.c fsl_flexcan_edma.c fsl_ftm.c fsl_gpio.c fsl_hsadc.c fsl_i2c.c fsl_i2c_edma.c fsl_llwu.c fsl_lptmr.c fsl_mpu.c fsl_pdb.c fsl_pit.c fsl_pmc.c fsl_pwm.c fsl_rcm.c fsl_sim.c fsl_smc.c fsl_trng.c fsl_uart.c fsl_uart_edma.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
    ../SRC/FWLIB/include/: fsl_port.h
  group HARDWARE
    ../SRC/HARDWARE/source/: clock_config.c OLED.c UI.c kalman.c parameter.c pid.c SMC.c SystemCar.c data_analyse.c FFT_arm.c Fuzzy_control.c Flash.c DoubleCarCom.c nrf2401.c UWB.c
  group CMSIS
    ../SRC/STARTUP/CMSIS/Lib/ARM/: arm_cortexM7lfsp_math.lib
